inherit kernel-resin

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

