LED_FILE_stm32mp1-disco = "/sys/class/leds/heartbeat/brightnes"
